# Keil uVision project example.uvprojx, settings and files
target target (6140001::V6.14.1::ARMCLANG)
  device: ES32F3696LT Eastsoft
  pack: Eastsoft.ES32_DFP.1.0.10
  cpu: IRAM(0x20000000,0x00018000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: out +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: ES32F36xx
  c include: ..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\EastSoft\ES32F36xx\Include;..\..\..\Drivers\ALD\ES32F36xx\Include;..\Inc;..\..\..\CherryUSB\common;..\..\..\CherryUSB\core;..\..\..\CherryUSB\class\cdc;..\..\..\CherryUSB\class\msc;..\..\..\CherryUSB\class\hid;..\..\..\CherryUSB\class\audio;..\..\..\CherryUSB\class\video;..\..\..\CherryUSB\demo
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group startup
    ../../../Drivers/CMSIS/Device/EastSoft/ES32F36xx/Startup/keil/: startup_es32f36xx.s
  group ald
    ../../../Drivers/ALD/ES32F36xx/Source/: ald_bkpc.c ald_cmu.c ald_dma.c ald_gpio.c ald_pmu.c ald_rmu.c ald_uart.c ald_iap.c utils.c
  group app
    ../Src/: main.c irq.c
    ../../../CherryUSB/demo/: cdc_acm_msc_template.c
  group CherryUSB
    ../../../CherryUSB/core/: usbd_core.c
    ../../../CherryUSB/class/msc/: usbd_msc.c
    ../../../CherryUSB/class/cdc/: usbd_cdc.c
    ../../../CherryUSB/class/hid/: usbd_hid.c
    ../../../CherryUSB/port/musb/: usb_dc_musb.c usb_glue_es.c
