# Keil uVision project example.uvprojx, settings and files
target target (6140001::V6.14.1::ARMCLANG)
  device: ES32F3696LT Eastsoft
  pack: Eastsoft.ES32_DFP.1.0.10
  cpu: IRAM(0x20000000,0x00018000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: out +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: ES32F36xx,
  c include: ..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\EastSoft\ES32F36xx\Include;..\..\..\Drivers\ALD\ES32F36xx\Include;..\Inc;..\..\..\CherryUSB\common;..\..\..\CherryUSB\core;..\..\..\CherryUSB\class\cdc;..\..\..\CherryUSB\class\hid;..\..\..\CherryUSB\class\msc;..\..\..\CherryUSB\class\hub;..\..\..\CherryUSB\class\audio;..\..\..\CherryUSB\class\video;..\..\..\CherryUSB\class\wireless;..\..\..\CherryUSB\osal;..\..\..\CherryUSB\third_party\FreeRTOS-10.4\include;..\..\..\CherryUSB\third_party\FreeRTOS-10.4\portable\GCC\ARM_CM3;..\..\..\CherryUSB\third_party\fatfs-0.14\source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group startup
    ../../../Drivers/CMSIS/Device/EastSoft/ES32F36xx/Startup/keil/: startup_es32f36xx.s
  group ald
    ../../../Drivers/ALD/ES32F36xx/Source/: ald_bkpc.c ald_cmu.c ald_dma.c ald_gpio.c ald_iap.c ald_pmu.c ald_rmu.c ald_uart.c utils.c
  group app
    ../Src/: main.c irq.c
    ../../../CherryUSB/demo/: usb_host.c
  group CherryUSB
    ../../../CherryUSB/core/: usbh_core.c
    ../../../CherryUSB/class/cdc/: usbh_cdc_acm.c
    ../../../CherryUSB/class/msc/: usbh_msc.c
    ../../../CherryUSB/class/hid/: usbh_hid.c
    ../../../CherryUSB/class/hub/: usbh_hub.c
    ../../../CherryUSB/osal/: usb_osal_freertos.c
    ../../../CherryUSB/port/musb/: usb_hc_musb.c usb_glue_es.c
  group FreeRTOS
    ../../../CherryUSB/third_party/FreeRTOS-10.4/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../CherryUSB/third_party/FreeRTOS-10.4/portable/MemMang/: heap_4.c
    ../../../CherryUSB/third_party/FreeRTOS-10.4/portable/GCC/ARM_CM3/: port.c
  group Fatfs
    ../../../CherryUSB/third_party/fatfs-0.14/source/: diskio.c ff.c ffsystem.c ffunicode.c
    ../../../CherryUSB/platform/none/: usbh_fatfs.c
